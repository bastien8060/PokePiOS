## buildroot/package/PokePi/Config.in
```kconfig
config BR2_PACKAGE_POKEPI
    bool "PokePi"
    help
        PokePi package.

        http://github.com/bastien8060/PokePi
```
